# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c tests.txt
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TP
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group Quoridor
    ./: QuoridorLib.c QuoridorLib.h gameGraphics.c gameGraphics.h
  group RIT
    ./: IRQ_RIT.c lib_RIT.c RIT.h
  group Joystick
    ./Joystick/: joystick.h lib_joystick.c
  group button_EINT
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
software components: CMSIS:CORE 5.4.0
